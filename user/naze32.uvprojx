# Keil uVision project naze32.uvprojx, settings and files
target naze32 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: naze32 +hex
  AfterMake: F:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\build\naze32.bin ..\build\naze32.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1,__ARM_ARCH_7M__,
  c misc: --gnu
  c include: ..\ap;..\include;..\arch\stm32;..\math;..\firmwares\rotorcraft;..\ext\libopencm3\include;..\firmwares\rotorcraft;..\modules;..\boards;..\firmwares\rotorcraft\stabilization;..\..\fly;..\mcu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usb
    ../ext/libopencm3/lib/usb/: usb.c usb_f103.c usb_control.c usb_standard.c
    ../ext/libopencm3/lib/stm32/: desig.c
    ../arch/stm32/: usb_ser_hw.c
  group user
    ../mcu/: ext.c mcu.c state.c pprz_debug.c
    ../ap/generated/: airframe.h
    ../boards/: naze32_rev5.h naze32_common.h
  group arch
    ../arch/stm32/: led_hw.c mcu_arch.c
    ../arch/stm32/mcu_periph/: i2c_arch.c adc_arch.c uart_arch.c gpio_arch.c sys_time_arch.c
    ../arch/stm32/subsystems/radio_control/: ppm_arch.c
    ../arch/stm32/subsystems/: settings_arch.c
    ../arch/stm32/subsystems/actuators/: actuators_pwm_arch.c actuators_shared_arch.c
  group math
    ../math/: pprz_trig_int.c pprz_algebra_int.c pprz_geodetic_int.c pprz_algebra_float.c pprz_geodetic_float.c pprz_algebra_double.c pprz_geodetic_double.c pprz_orientation_conversion.c
  group boards
    ../boards/: baro_board_bmp280_i2c.c
  group startup
    ./: startup_stm32f10x_md.s
  group modules
    ../modules/datalink/missionlib/: blocks.c waypoints_.c mission_manager.c
    ../modules/datalink/: mavlink.c mavlink_decoder.c
    ../modules/sensors/: mag_hmc58xx.c
    ../modules/gps/: gps_ubx_ucenter.c
    ../modules/calibration/: send_imu_mag_current.c
  group firmwares
    ../firmwares/rotorcraft/: main.c datalink.c autopilot.c navigation.c stabilization.c rotorcraft_telemetry.c
    ../firmwares/rotorcraft/guidance/: guidance_v.c guidance_h.c guidance_flip.c guidance_indi.c guidance_v_ref.c guidance_h_ref.c guidance_v_adapt.c
    ../firmwares/rotorcraft/stabilization/: stabilization_rate.c stabilization_none.c stabilization_attitude_quat_int.c stabilization_attitude_rc_setpoint.c stabilization_attitude_ref_quat_int.c stabilization_attitude_quat_transformations.c
  group peripherals
    ../peripherals/: ms5611.c hmc58xx.c mpu60x0.c ms5611_i2c.c bmp280_i2c.c mpu60x0_i2c.c
  group libopencm3
    ../ext/libopencm3/lib/stm32/f1/: rcc.c adc.c gpio.c flash.c timer.c usart.c
    ../ext/libopencm3/lib/cm3/: scb.c nvic.c assert.c systick.c
    ../ext/libopencm3/lib/stm32/common/: i2c_common_all.c rcc_common_all.c adc_common_v1.c gpio_common_all.c timer_common_all.c usart_common_all.c flash_common_f01.c usart_common_f124.c
  group mcu_periph
    ../mcu_periph/: i2c.c uart.c sys_time.c
  group subsystems
    ../subsystems/: ins.c gps.c imu.c ahrs.c settings.c electrical.c actuators.c commands.c radio_control.c
    ../subsystems/radio_control/: ppm.c
    ../subsystems/ins/: ins_int.c vf_float.c
    ../subsystems/gps/: gps_ubx.c
    ../subsystems/datalink/: downlink.c telemetry.c pprz_transport.c
    ../subsystems/navigation/: waypoints.c common_flight_plan.c
    ../subsystems/ahrs/: ahrs_aligner.c ahrs_int_cmpl_quat.c ahrs_int_cmpl_quat_wrapper.c
    ../subsystems/actuators/: motor_mixing.c
    ../subsystems/imu/: imu_mpu60x0_i2c.c
software components: CMSIS:CORE 4.3.0
